# Keil uVision project Demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\RGB;.\driverlib;.\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c startup_rvmdk.S
  group Driver
    ./driverlib/: adc.c adc.h aes.c aes.h can.c can.h comp.c comp.h cpu.c cpu.h crc.c crc.h debug.h des.c des.h eeprom.c eeprom.h emac.c emac.h epi.c epi.h flash.c flash.h fpu.c fpu.h gpio.c gpio.h hibernate.c hibernate.h i2c.c i2c.h interrupt.c interrupt.h lcd.c lcd.h mpu.c mpu.h onewire.c onewire.h pin_map.h pwm.c pwm.h qei.c qei.h readme.txt rom.h rom_map.h rtos_bindings.h shamd5.c shamd5.h ssi.c ssi.h sw_crc.c sw_crc.h sysctl.c sysctl.h sysexc.c sysexc.h systick.c systick.h timer.c timer.h uart.c uart.h udma.c udma.h usb.c usb.h watchdog.c watchdog.h
