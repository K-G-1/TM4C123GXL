# Keil uVision project Demo.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Demo
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1
  c include: ..\Buttons;.\inc;.\driverlib;.\drivers;.\utils;.\inc;..\Timer_pwm;.\drivers\IIC;.\drivers\oled
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c startup_rvmdk.S
    ./utils/: uartstdio.c
  group DriverLIB
    ./driverlib/: adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c onewire.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
  group Drivers
    ./drivers/: rgb.c buttons.c
    ./drivers/IIC/: IIC.c
    ./drivers/oled/: oled.c
    ./utils/: softi2c.c
